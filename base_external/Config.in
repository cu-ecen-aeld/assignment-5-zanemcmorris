## base_external/Config.in
```kconfig
menu "AESD_assignment"
source "$BR2_EXTERNAL_project_base_PATH/package/aesd-assignments/Config.in"
endmenu
```
